options:
  parameters:
    author: kawakey
    generate_options: qt_gui
    id: integration
    output_language: python
    title: CTCSS
  states: {}

blocks:
- name: atten_out
  id: variable_function_probe
  parameters:
    block_id: atten_out_signal
    function_name: level
    poll_rate: '10'
    value: '0.2'
  states: {}
- name: audio_rate
  id: variable
  parameters:
    value: '48000'
  states: {}
- name: frequency
  id: variable
  parameters:
    value: '433500000'
  states: {}
- name: fsk_deviation_hz
  id: variable
  parameters:
    value: '5000'
  states: {}
- name: iq_rate
  id: variable
  parameters:
    value: '192000'
  states: {}
- name: mod_selector
  id: variable_qtgui_chooser
  parameters:
    label0: NBFM
    label1: AM
    num_opts: '2'
    option0: '0'
    option1: '1'
    type: int
    value: '0'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '1000000'
  states: {}
- name: sim_power
  id: variable_qtgui_chooser
  parameters:
    label: Symulacja Tonu 1750Hz
    label0: Cisza
    label1: PIK!
    num_opts: '2'
    option0: '0'
    option1: '1'
    type: real
    value: '0'
    widget: radio_buttons
  states: {state: disabled}
- name: analog_const_source_x_0
  id: analog_const_source_x
  parameters:
    const: '0'
    type: float
  states: {}
- name: analog_const_source_x_0_0
  id: analog_const_source_x
  parameters:
    const: sim_power
    type: float
  states: {state: disabled}
- name: analog_ctcss_squelch_ff_0
  id: analog_ctcss_squelch_ff
  parameters:
    freq: '123'
    gate: 'False'
    len: '0'
    level: '0.01'
    ramp: '0'
    rate: audio_rate
  states: {}
- name: analog_fm_deemph_0
  id: analog_fm_deemph
  parameters:
    samp_rate: samp_rate
    tau: '75e-6'
  states: {}
- name: analog_nbfm_tx_0_0
  id: analog_nbfm_tx
  parameters:
    audio_rate: '32000'
    fh: '-1.0'
    max_dev: 5e3
    quad_rate: '32000'
    tau: '75e-6'
  states: {}
- name: analog_quadrature_demod_cf_0
  id: analog_quadrature_demod_cf
  parameters:
    gain: iq_rate/(2*math.pi*fsk_deviation_hz)
  states: {}
- name: atten_out_signal
  id: blocks_probe_signal_x
  parameters:
    type: float
  states: {}
- name: band_pass_filter_0
  id: band_pass_filter
  parameters:
    decim: '1'
    gain: '1'
    high_cutoff_freq: '1800'
    low_cutoff_freq: '1700'
    samp_rate: samp_rate
    type: fir_filter_fcc
    width: '1'
    win: window.WIN_HAMMING
  states: {}
- name: blocks_add_const_vxx_0
  id: blocks_add_const_vxx
  parameters:
    const: '1'
    type: float
  states: {}
- name: blocks_complex_to_mag_squared_0
  id: blocks_complex_to_mag_squared
  parameters: {}
  states: {}
- name: blocks_float_to_complex_0
  id: blocks_float_to_complex
  parameters: {}
  states: {}
- name: blocks_selector_0
  id: blocks_selector
  parameters:
    enabled: 'True'
    input_index: mod_selector
    num_inputs: '2'
    num_outputs: '1'
    output_index: '0'
    type: complex
  states: {}
- name: blocks_threshold_ff_0
  id: blocks_threshold_ff
  parameters:
    high: '100'
    init: '0'
    low: '-100'
  states: {}
- name: epy_block_0
  id: epy_block
  parameters:
    _source_code: |-
      import numpy as np
      from gnuradio import gr


      class repeater_control(gr.sync_block):
          """
          Logika sterująca przemiennikiem:
          - Wejście 0: Surowe Audio (zdemodulowane)
          - Wejście 1: Detekcja CTCSS (sygnał 0.0 lub 1.0)
          - Wejście 2: Detekcja Tonu Mocy (sygnał 0.0 lub 1.0)
          
          - Wyjście 0: Audio Bramkowane (idzie do nadajnika)
          - Wyjście 1: Poziom Mocy (mnożnik dla bloku Multiply)
          """

          def __init__(self, sample_rate=48000, cooldown_seconds=2.0):
              gr.sync_block.__init__(
                  self,
                  name='Repeater Logic Controller',   
                  in_sig=[np.float32, np.float32, np.float32],
                  out_sig=[np.float32, np.float32]
              )
              
              self.sample_rate = sample_rate
              self.cooldown_samples = int(sample_rate * cooldown_seconds)
              
              self.current_gain = 0.2  # Domyślna moc
              self.high_gain = 1.0     # Maksymalna moc
              self.low_gain = 0.2      # Minimalna moc
              
              self.timer = 0           # Licznik czasu do debouncingu przełączania mocy

          def work(self, input_items, output_items):
              audio_in = input_items[0]
              ctcss_signal = input_items[1]
              power_cmd_signal = input_items[2]
              
              audio_out = output_items[0]
              gain_out = output_items[1]
              
              squelch_mask = (ctcss_signal > 0.5).astype(np.float32)
              
              audio_out[:] = audio_in * squelch_mask
              
              tone_detected = np.max(power_cmd_signal) > 0.5
              
              if self.timer > 0:
                  self.timer -= len(audio_in)
              
              if tone_detected and self.timer <= 0:
                  if self.current_gain == self.low_gain:
                      self.current_gain = self.high_gain
                  else:
                      self.current_gain = self.low_gain

                  self.timer = self.cooldown_samples
                  
              gain_out[:] = self.current_gain
              
              return len(output_items[0])
    cooldown_seconds: '1.0'
    sample_rate: samp_rate
  states: {}
- name: high_pass_filter_0
  id: high_pass_filter
  parameters:
    cutoff_freq: '300'
    decim: '1'
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_fff
    width: '50'
    win: window.WIN_HAMMING
  states: {}
- name: iio_pluto_sink_0
  id: iio_pluto_sink
  parameters:
    attenuation1: atten_out
    bandwidth: '20000000'
    buffer_size: '32768'
    cyclic: 'False'
    filter_source: '''Auto'''
    frequency: frequency
    samplerate: samp_rate
    type: fc32
  states: {}
- name: iio_pluto_source_0
  id: iio_pluto_source
  parameters:
    bandwidth: '20000000'
    bbdc: 'True'
    buffer_size: '32768'
    filter_source: '''Auto'''
    frequency: frequency
    gain1: '''slow_attack'''
    quadrature: 'True'
    rfdc: 'True'
    samplerate: samp_rate
    type: fc32
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    cutoff_freq: 6e3
    decim: '1'
    gain: '1'
    samp_rate: audio_rate
    type: fir_filter_ccf
    width: 2e3
    win: window.WIN_HAMMING
  states: {}
- name: low_pass_filter_1
  id: low_pass_filter
  parameters:
    cutoff_freq: '260'
    decim: '1'
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_fff
    width: '50'
    win: window.WIN_HAMMING
  states: {}
- name: note_0
  id: note
  parameters:
    note: not used right now
  states: {}
- name: note_1_0
  id: note
  parameters:
    note: Logik python
  states: {}
- name: note_1_0_0
  id: note
  parameters:
    note: symulacja tonu 1750 Hz
  states: {state: disabled}
- name: qtgui_freq_sink_x_0_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    type: complex
  states: {}
- name: qtgui_freq_sink_x_1
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    name: '"AUDIO"'
    type: float
  states: {}
- name: qtgui_freq_sink_x_2
  id: qtgui_freq_sink_x
  parameters:
    bw: audio_rate
    fc: '0'
    fftsize: '1024'
    name: '"RECIVED"'
    type: float
  states: {}
- name: qtgui_number_sink_0
  id: qtgui_number_sink
  parameters:
    graph_type: qtgui.NUM_GRAPH_HORIZ
    name: '"CTCSS"'
    type: float
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    size: '4000'
    srate: samp_rate
    type: float
  states: {}
- name: qtgui_time_sink_x_0_0
  id: qtgui_time_sink_x
  parameters:
    size: '64000'
    srate: samp_rate
    type: complex
  states: {}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: '4'
    interp: '1'
    type: fff
  states: {}
- name: rational_resampler_xxx_0_0
  id: rational_resampler_xxx
  parameters:
    decim: '1'
    interp: '64'
    type: ccc
  states: {}

connections:
- [analog_const_source_x_0, '0', blocks_float_to_complex_0, '1']
- [analog_const_source_x_0_0, '0', epy_block_0, '2']
- [analog_ctcss_squelch_ff_0, '0', epy_block_0, '1']
- [analog_ctcss_squelch_ff_0, '0', qtgui_number_sink_0, '0']
- [analog_fm_deemph_0, '0', epy_block_0, '0']
- [analog_fm_deemph_0, '0', qtgui_freq_sink_x_1, '0']
- [analog_fm_deemph_0, '0', qtgui_time_sink_x_0, '0']
- [analog_nbfm_tx_0_0, '0', blocks_selector_0, '0']
- [analog_quadrature_demod_cf_0, '0', band_pass_filter_0, '0']
- [analog_quadrature_demod_cf_0, '0', rational_resampler_xxx_0, '0']
- [band_pass_filter_0, '0', blocks_complex_to_mag_squared_0, '0']
- [blocks_add_const_vxx_0, '0', blocks_float_to_complex_0, '0']
- [blocks_complex_to_mag_squared_0, '0', blocks_threshold_ff_0, '0']
- [blocks_float_to_complex_0, '0', blocks_selector_0, '1']
- [blocks_selector_0, '0', iio_pluto_sink_0, '0']
- [blocks_selector_0, '0', rational_resampler_xxx_0_0, '0']
- [blocks_threshold_ff_0, '0', epy_block_0, '2']
- [epy_block_0, '0', analog_nbfm_tx_0_0, '0']
- [epy_block_0, '0', blocks_add_const_vxx_0, '0']
- [epy_block_0, '1', atten_out_signal, '0']
- [high_pass_filter_0, '0', analog_fm_deemph_0, '0']
- [iio_pluto_source_0, '0', low_pass_filter_0, '0']
- [low_pass_filter_0, '0', analog_quadrature_demod_cf_0, '0']
- [low_pass_filter_1, '0', analog_ctcss_squelch_ff_0, '0']
- [rational_resampler_xxx_0, '0', high_pass_filter_0, '0']
- [rational_resampler_xxx_0, '0', low_pass_filter_1, '0']
- [rational_resampler_xxx_0, '0', qtgui_freq_sink_x_2, '0']
- [rational_resampler_xxx_0_0, '0', qtgui_freq_sink_x_0_0, '0']
- [rational_resampler_xxx_0_0, '0', qtgui_time_sink_x_0_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
